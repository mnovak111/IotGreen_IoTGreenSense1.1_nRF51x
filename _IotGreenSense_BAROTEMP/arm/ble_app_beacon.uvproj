# Keil uVision project ble_app_beacon.uvproj, settings and files
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_beacon +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_NRF6310
  c misc: --c99
  c include: ..\..\..\..\Include;..\..\..\..\Include\app_common;..\..\..\..\Include\ble;..\..\..\..\Include\ble\ble_services;..\..\..\..\Include\s110;..\..\..\..\Include\sd_common;..\..\_IotGreenSense_BAROTEMP;..\..\..\..\Source\spi_master
  memory RVCT4: ROM 0x16000 size 0x29000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Startup Code
    ../../../../Source/templates/: system_nrf51.c
    ../../../../Source/templates/arm/: arm_startup_nrf51.s
  group Source Code
    ./../: main.c
    ../: mpl3115.c cc110l.c hdc1008.c
  group Services
    ../../../../Source/ble/ble_services/: ble_srv_common.c
  group Libraries
    ../../../../Source/ble/: ble_advdata.c ble_debug_assert_handler.c ble_radio_notification.c
    ../../../../Source/sd_common/: softdevice_handler.c
    ../: spi_master_mnhs.c
    ../../../../Source/nrf_delay/: nrf_delay.c
    ../../../../Source/twi_master/: twi_hw_master_SD.c
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  cpu: as above
  output: ble_app_beacon +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_NRF6310
  c misc: --c99
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\s110;..\..\..\..\..\Include\sd_common
  memory RVCT4: ROM 0x16000 size 0x9000
  memory RVCT9: RAM 0x20002000 size 0x2000
